options:
  parameters:
    generate_options: qt_gui
    id: am_receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: antenna_gain
  id: variable_qtgui_range
  parameters:
    label: antenna_gain
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    label: audio_gain
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: freq_offset
    start: '-5e3'
    step: '100'
    stop: 5e3
    value: '0'
  states: {}
- name: intermediate_freq
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: low_pass_cutoff
  id: variable
  parameters:
    value: audio_samp_rate/2
  states: {}
- name: lowpass_squared_signal
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: low_pass_cutoff
    gain: '1.0'
    samp_rate: samp_rate
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: upsample_factor
  id: variable
  parameters:
    value: '10'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: intermediate_freq + low_pass_cutoff
    low_cutoff_freq: intermediate_freq - low_pass_cutoff
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: audio_samp_rate
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: upsample_factor
    taps: lowpass_squared_signal
    type: fff
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: low_pass_cutoff
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    name: '"Received baseband signal"'
    rate: '1'
    type: float
  states: {}
- name: qtgui_sink_x_1_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    name: '"Filtered IF"'
    rate: '1'
    type: float
  states: {}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@2
    name: '"Squared received signal"'
    rate: '1'
    type: float
  states: {}
- name: qtgui_sink_x_2_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@3
    name: '"Filtered squared signal"'
    rate: '1'
    type: float
  states: {}
- name: qtgui_sink_x_3
  id: qtgui_sink_x
  parameters:
    bw: '44100'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@4
    name: '"Decimated squared signal"'
    rate: '1'
    type: float
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: '"Received baseband signal"'
    label1: '"Filtered IF"'
    label2: Squared signal
    label3: Filtered squared signal
    label4: Decimated squared signal
    num_tabs: '5'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate/2
    center_freq0: carrier_freq-intermediate_freq+freq_offset
    clock_rate: 30.72e6
    gain0: antenna_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: filtered_squared_signal
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: filtered_squared_signal
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_multiply_xx_1, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_1, '1']
- [band_pass_filter_0, '0', qtgui_sink_x_1_0_0, '0']
- [blocks_complex_to_real_0, '0', band_pass_filter_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_sink_x_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_1, '0', qtgui_sink_x_2, '0']
- [blocks_throttle2_0, '0', audio_sink_0, '0']
- [fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [fir_filter_xxx_0, '0', qtgui_sink_x_3, '0']
- [low_pass_filter_0_0, '0', qtgui_sink_x_2_0, '0']
- [low_pass_filter_0_0, '0', virtual_sink_2, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_real_0, '0']
- [virtual_source_2, '0', fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
