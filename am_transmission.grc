options:
  parameters:
    generate_options: qt_gui
    id: am_transmission
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: audio_volume_sink
  id: variable
  parameters:
    value: '1'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: intermediate_freq
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: low_pass_cutoff
  id: variable
  parameters:
    value: audio_samp_rate/2
  states: {}
- name: lowpass_squared_signal
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: low_pass_cutoff
    gain: '1.0'
    samp_rate: samp_rate
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: upsample_factor
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carrier_freq-intermediate_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: intermediate_freq + low_pass_cutoff
    low_cutoff_freq: intermediate_freq - low_pass_cutoff
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume_sink
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: audio_samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      WAV file
      Fs=44100 Hz, 16 bits
    file: hino_paysandu.wav
    repeat: 'True'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: upsample_factor
    taps: lowpass_squared_signal
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: upsample_factor
    taps: '1'
    type: fff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: low_pass_cutoff
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    alias: audio
    bw: '44100'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    name: '"Audio FFT (Hz)"'
    rate: '1'
    type: float
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    alias: upsampled_audio
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    name: '"Upsampled Audio FFT (Hz)"'
    rate: '1'
    type: float
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    alias: upsampled_filtered_audio
    bw: audio_samp_rate*upsample_factor
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@2
    name: '"Upsampled Filtered Audio FFT (Hz)"'
    rate: '1'
    type: float
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@3
    name: '"AM Transmitted signal"'
    rate: '1'
    type: float
  states: {}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@4
    name: '"Received baseband signal"'
    rate: '1'
    type: float
  states: {}
- name: qtgui_sink_x_1_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@5
    name: '"Filtered IF"'
    rate: '1'
    type: float
  states: {}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@6
    name: '"Squared received signal"'
    rate: '1'
    type: float
  states: {}
- name: qtgui_sink_x_2_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@7
    name: '"Filtered squared signal"'
    rate: '1'
    type: float
  states: {}
- name: qtgui_sink_x_3
  id: qtgui_sink_x
  parameters:
    bw: '44100'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@8
    name: '"Decimated squared signal"'
    rate: '1'
    type: float
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Audio
    label1: Upsampled audio
    label2: upsampled filtered audio
    label3: Transmitted signal
    label4: '"Received baseband signal"'
    label5: '"Filtered IF"'
    label6: '"Squared signal"'
    label7: Filtered squared signal
    label8: Decimated squared signal
    num_tabs: '9'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: upsample_out
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: transmitted_signal
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: filtered_squared_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: upsample_out
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: transmitted_signal
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: filtered_squared_signal
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [band_pass_filter_0, '0', blocks_multiply_xx_1, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_1, '1']
- [band_pass_filter_0, '0', qtgui_sink_x_1_0_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_1, '0']
- [blocks_multiply_xx_0_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_sink_x_1_0, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_1, '0', qtgui_sink_x_2, '0']
- [blocks_throttle2_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [fir_filter_xxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [fir_filter_xxx_0, '0', qtgui_sink_x_3, '0']
- [interp_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_sink_x_0_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', virtual_sink_0, '0']
- [low_pass_filter_0_0, '0', qtgui_sink_x_2_0, '0']
- [low_pass_filter_0_0, '0', virtual_sink_2, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_1, '0', blocks_multiply_xx_0_0, '0']
- [virtual_source_2, '0', fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
