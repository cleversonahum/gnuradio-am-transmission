options:
  parameters:
    generate_options: qt_gui
    id: am_transmitter
    output_language: python
    title: am_transmitter
  states: {}

blocks:
- name: antenna_gain
  id: variable_qtgui_range
  parameters:
    label: antenna_gain
    start: '0'
    step: '1'
    stop: '50'
    value: '25'
  states: {}
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    label: audio_gain
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: intermediate_freq
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: low_pass_cutoff
  id: variable
  parameters:
    value: audio_samp_rate/2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: upsample_factor
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: audio_samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      WAV file
      Fs=44100 Hz, 16 bits
    file: hino_paysandu.wav
    repeat: 'True'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: upsample_factor
    taps: '1'
    type: fff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    alias: audio
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    name: '"Audio FFT (Hz)"'
    rate: '1'
    type: float
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    alias: upsampled_audio
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    name: '"Upsampled Audio FFT (Hz)"'
    rate: '1'
    type: float
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    alias: upsampled_filtered_audio
    bw: audio_samp_rate*upsample_factor
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@2
    name: '"Upsampled Filtered Audio FFT (Hz)"'
    rate: '1'
    type: float
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Audio
    label1: Upsampled audio
    label2: upsampled filtered audio
    num_tabs: '3'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: samp_rate/2
    center_freq0: carrier_freq
    gain0: '1'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: upsample_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: upsample_out
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [interp_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_sink_x_0_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_add_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
