options:
  parameters:
    generate_options: qt_gui
    id: am_trans
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 18e3
    gain: '2'
    samp_rate: samp_rate
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 100e3
    step: '100'
    stop: 200e3
    value: 150e3
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '100'
    stop: '10000'
    value: '800'
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    min_len: '1'
    orient: Qt.Horizontal
    start: '0'
    step: '100'
    stop: '2'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 480e3
  states: {}
- name: signal_source
  id: variable_qtgui_chooser
  parameters:
    label0: Audio
    label1: Cossine
    num_opts: '2'
    option1: '0'
    type: int
    value: '1'
  states: {}
- name: taps_rx
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: 180e3
    low_cutoff_freq: 120e3
    samp_rate: samp_rate
    type: band_pass
    width: '2000'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: vol
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '20'
    stop: '2'
    value: '2'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '10'
    audio_pass: '18000'
    audio_stop: '19000'
    chan_rate: samp_rate
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ka
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: signal_source
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_throttle_2
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/cleversonahum/Documents/trans-digital-ufpa/gnu-am-transmission/super_mario_medley.wav
    repeat: 'True'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '2'
    taps: taps_rx
    type: fcc
  states: {state: disabled}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '10'
    taps: audio_taps
    type: fff
  states: {}
- name: note_0
  id: note
  parameters:
    note: WAV 16 bits 48kHz
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: transmitter
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: transmitter
  states: {}

connections:
- [analog_am_demod_cf_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_sig_source_x_0, '0', blocks_selector_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0, '0', analog_am_demod_cf_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_2, '0', interp_fir_filter_xxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_throttle_2, '0']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle_2, '0', qtgui_sink_x_1, '0']
- [blocks_throttle_2, '0', virtual_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_2, '0']
- [fir_filter_xxx_0, '0', analog_am_demod_cf_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_selector_0, '1']
- [virtual_source_0, '0', blocks_float_to_complex_0, '0']
- [virtual_source_0, '0', fir_filter_xxx_0, '0']

metadata:
  file_format: 1
